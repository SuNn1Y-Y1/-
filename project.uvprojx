# Keil uVision project project.uvprojx, settings and files
target Sunny (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER,HSE_VALUE=12000000
  c include: .\CMSIS;.\USER;.\STM32F10x_StdPeriph_Driver\inc;.\USER\inc;.\inc;.\public;.\ov7670;.\freertos\include;.\freertos\portable\RVDS\ARM_CM3;.\freertos;.\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md_vl.s
  group USER
    ./USER/: main.c
    ./USER/src/: led.c dma.c iwdg.c rs485.c malloc.c adc.c goertzel.c laser_board.c iic.c dac.c distance_calc.c phase_analyse.c range_measure.c
    ./src/: key.c motor.c relay.c spi.c
  group DRIVER
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_flash.c
  group public
    ./public/: systick.c suart1.c
  group FREERTOS
    ./freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./freertos/portable/MemMang/: heap_4.c
    ./freertos/portable/RVDS/ARM_CM3/: port.c
  group TIM
    ./TIM/: tim_sys.c tim1_pwm.c
